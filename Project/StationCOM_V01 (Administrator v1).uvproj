# Keil uVision project StationCOM_V01 (Administrator v1).uvproj, settings and files
target TCAS (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: StationCOM_V01 +hex
  c flags: Optim=4
  c include: ..\SourceFiles\h
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group LPC2378
    ./: LPC2300.s
  group Main
    ../SourceFiles/lpm/: Main.c globals.c InitTcas.c
  group Spoi
    ../SourceFiles/modules/spoi/: GpioInit.c RealTimeClk.c SystemTimer.c Uart.c WdtInit.c EXT_RTC.c
  group RT Agent
    ../RT Agent/: RTA_Config.c
  group Com Port
    ../RT Agent/: Serial.c Retarget.c
  group Comm
    ../SourceFiles/modules/Communication/: BitManip.c RxAndTx.c checkSum.c crc.c PPSInit.c
  group GPIO
    ../SourceFiles/modules/GPIO/: di.c do.c
  group Loco
    ../SourceFiles/modules/Loco/: Loco.c
  group RM
    ../SourceFiles/modules/RM/: rm.c
  group CAN
    ../SourceFiles/modules/CAN/: CAN.c
  group TIMER
    ../SourceFiles/modules/TIMER/: Timer.c
  group GPS
    ../SourceFiles/modules/GPS/: Gps.c
  group Station
    ./: station.c
  group DataLogger
    ../SourceFiles/modules/DataLogger/: DataLogger.c
  group Encryption
    ../SourceFiles/modules/Encryption/: Encrpt.c
